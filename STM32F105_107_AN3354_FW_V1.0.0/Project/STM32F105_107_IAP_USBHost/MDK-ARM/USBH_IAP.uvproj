# Keil uVision project USBH_IAP.uvproj, settings and files
target USBH_IAP (ARM-ADS)
  device: STM32F107VB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBH_MSC
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STM3210C_EVAL,HOST_MODE_ENABLED,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\Third_Party\efsl\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32_USB_HOST_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group Driver
    ../../../Libraries/STM32_USB_HOST_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group User
    ../src/: main.c stm32f10x_it.c usbh_usr.c usb_bsp.c flash_layer.c command.c
  group EFSL
    ../../../Utilities/Third_Party/efsl/src/: file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c dir.c disc.c efs.c extract.c fat.c
  group MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fs_interface.c usbh_msc_scsi.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group CMSIS
    ../src/: system_stm32f10x.c
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_i2c.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c stm3210c_eval.c stm3210c_eval_ioe.c
