# Keil uVision project SysTick.uvproj, settings and files
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x3d000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\STM3210C-EVAL\STM3210C-EVAL.sct
  group User
    ../src/: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_sdio.c stm32f10x_dma.c
  group CMSIS
    ../src/: system_stm32f10x.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/: stm32_eval.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s startup_stm32f10x_hd_vl.s
  group Doc
    ../: readme.txt
