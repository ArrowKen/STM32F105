# IAR project USBH_IAP.ewp, settings and files
configuration STM3210C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; HOST_MODE_ENABLED
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\Third_Party\efsl\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32_USB_HOST_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_IAP.bin
  ILINK.IlinkOutputFile: USBH_IAP.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c
  group EFSL
    ../../../Utilities/Third_Party/efsl/src/: dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_ioe.c stm3210c_eval_lcd.c
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group USB_Host/Class/MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fs_interface.c usbh_msc_scsi.c
  group USB_Host/Core
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../../../Libraries/STM32_USB_HOST_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group User
    ../src/: command.c flash_layer.c main.c stm32f10x_it.c usb_bsp.c usbh_usr.c
